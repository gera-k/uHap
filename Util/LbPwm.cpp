
#include "math.h"
#include "LbPwm.h"

void LbPWM::rgb(uint8_t& R, uint8_t& G, uint8_t& B)
{
    if (!_on)
    {
        R = G = B = 0;
        return;
    }

    float V = (float)_v / 100.;
    float S = (float)_s / 100.;
    float H = (float)_h;
    
    float C = V * S;
    float X = C * (1. - fabs(fmod(H/60, 2) - 1));
    float m = V - C;
    float r, g, b;
    if (H < 60)
    {
        r = C; g = X, b = 0;
    }
    else if (H < 120)
    {
        r = X; g = C, b = 0;
    }
    else if (H < 180)
    {
        r = 0; g = C, b = X;
    }
    else if (H < 240)
    {
        r = 0; g = X, b = C;
    }
    else if (H < 300)
    {
        r = X; g = 0, b = C;
    }
    else
    {
        r = C; g = 0, b = X;
    }

    R = (uint8_t)((r + m) * 255);
    G = (uint8_t)((g + m) * 255);
    B = (uint8_t)((b + m) * 255);

    //Log::Msg("h s v %d %d %d  RGB %02X %02X %02X\n", _h, _s, _v, R, G, B);
}

const uint8_t LbPWM::_b2p[] =
{
	 0,  0,  0,  0,   0,   0,   0,   0,   1,   1,   1,   1,   1,   1,   1,   1,   1,   2,   2,   2,
	 2,  2,  2,  3,   3,   3,   3,   3,   4,   4,   4,   5,   5,   5,   6,   6,   6,   7,   7,   8,
	 8,  9,  9, 10,  10,  11,  12,  13,  13,  14,  15,  16,  17,  18,  19,  20,  21,  23,  24,  25,
	27, 28, 30, 32,  34,  36,  38,  40,  42,  45,  48,  50,  53,  56,  60,  63,  67,  71,  75,  79,
	83, 88, 93, 99, 104, 110, 117, 123, 131, 138, 146, 154, 163, 173, 183, 193, 204, 216, 228, 241,
	255
};
const uint8_t LbPWM::_v2p[] =
{
	  0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,   0,
	  0,   0,   1,   1,   1,   1,   1,   1,   1,   1,   1,   1,   1,   1,   1,   1,
	  1,   1,   1,   1,   1,   1,   1,   1,   1,   1,   2,   2,   2,   2,   2,   2,
	  2,   2,   2,   2,   2,   2,   2,   2,   2,   3,   3,   3,   3,   3,   3,   3,
	  3,   3,   3,   3,   3,   4,   4,   4,   4,   4,   4,   4,   4,   4,   5,   5,
	  5,   5,   5,   5,   5,   5,   6,   6,   6,   6,   6,   6,   6,   7,   7,   7,
	  7,   7,   8,   8,   8,   8,   8,   9,   9,   9,   9,   9,  10,  10,  10,  10,
	 11,  11,  11,  11,  12,  12,  12,  12,  13,  13,  13,  14,  14,  14,  15,  15,
	 15,  16,  16,  16,  17,  17,  18,  18,  18,  19,  19,  20,  20,  21,  21,  22,
	 22,  23,  23,  24,  24,  25,  25,  26,  26,  27,  28,  28,  29,  30,  30,  31,
	 32,  32,  33,  34,  35,  35,  36,  37,  38,  39,  40,  40,  41,  42,  43,  44,
	 45,  46,  47,  48,  49,  51,  52,  53,  54,  55,  56,  58,  59,  60,  62,  63,
	 64,  66,  67,  69,  70,  72,  73,  75,  77,  78,  80,  82,  84,  86,  88,  90,
	 91,  94,  96,  98, 100, 102, 104, 107, 109, 111, 114, 116, 119, 122, 124, 127,
	130, 133, 136, 139, 142, 145, 148, 151, 155, 158, 161, 165, 169, 172, 176, 180,
	184, 188, 192, 196, 201, 205, 210, 214, 219, 224, 229, 234, 239, 244, 250, 255
};

